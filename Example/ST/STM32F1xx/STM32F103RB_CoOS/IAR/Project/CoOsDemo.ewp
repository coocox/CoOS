# IAR project CoOsDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: ..\..\..\BSPLIB\inc\; ..\APP\; ..\..\..\..\..\..\CoOS\portable\; ..\..\..\..\..\..\CoOS\kernel\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: CoOsDemo.srec
  ILINK.IlinkOutputFile: CoOsDemo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ; Source\; CoOS\; CoOS\portable\; CoOS\kernel\; lib\inc\
  ICCARM.CCOptLevel: 3
  group App
    ../APP/: AppConfig.c AppConfig.h LED_4bit.c main.c OsConfig.h
  group CMSIS_LIB
    ../../../BSPLIB/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_conf.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_it.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_tim1.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../../../BSPLIB/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_it.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_systick.c stm32f10x_usart.c
  group CooCox RTOS
    ../../../../../../CoOS/kernel/: coocox.h CoOS.h core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c OsCore.h OsError.h OsEvent.h OsFlag.h OsKernelHeap.h OsMM.h OsMutex.h OsQueue.h OsServiceReq.h OsTask.h OsTime.h OsTimer.h queue.c sem.c serviceReq.c task.c time.c timer.c utility.c utility.h
  group ewarm
    ../../../BSPLIB/src/startup/IAR/: cortexm3_macro.s
    ../../../../../../CoOS/portable/IAR/: portForM3.asm
    ../../../BSPLIB/src/: stm32f10x_vector.c
  group Port
    ../../../../../../CoOS/portable/: arch.c OsArch.h
