# Keil uVision project CoOsDemo.uvproj, settings and files
target flash-Colink (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTOSDemo-flash
  c include: ..\..\..\BSPLIB\inc;..\App;..\..\..\..\..\..\CoOS\kernel;..\..\..\..\..\..\CoOS\portable
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Demo App
    ../App/: main.c AppConfig.c LCD_4bit.c AppConfig.h OsConfig.h
  group System
    ../../../BSPLIB/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_conf.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_it.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim1.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../../../BSPLIB/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_it.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_systick.c stm32f10x_usart.c
    ../../../BSPLIB/src/startup/MDK/: cortexm3_macro.s startup_stm32f10x_ld.s
  group Port
    ../../../../../../CoOS/portable/: arch.c OsArch.h
    ../../../../../../CoOS/portable/Keil/: port.c
  group CoOS
    ../../../../../../CoOS/kernel/: coocox.h CoOS.h core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c OsCore.h OsError.h OsEvent.h OsFlag.h OsKernelHeap.h OsMM.h OsMutex.h OsQueue.h OsServiceReq.h OsTask.h OsTime.h OsTimer.h queue.c sem.c serviceReq.c task.c time.c timer.c utility.c utility.h
target flash-ULINK2 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: RTOSDemo-flash
  c flags: Optim=1
  c include: ..\lib\inc;..\App;..\CoOS;..\CoOS\kernel;..\CoOS\portable
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target flash-Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: RTOSDemo-flash
  c flags: Optim=1
  c include: ..\lib\inc;..\App;..\CoOS;..\CoOS\kernel;..\CoOS\portable
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
