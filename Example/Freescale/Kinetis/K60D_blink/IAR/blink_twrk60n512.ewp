# IAR project blink_twrk60n512.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\..\BSPLIB\inc; ..\..\BSPLIB\src; ..\..\cmsis; ..\..\cmsis\include; ..\..\..\..\..\CoOS\portable; ..\..\..\..\..\CoOS\kernel
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: 512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: lwip_twrk60n512.srec
  group (top)
    ../: AppConfig.h main.c OsConfig.h
    ./: isr.h low_init.c vectors.c vectors.h
  group BSPLIB/enet
    ../../BSPLIB/src/enet/: enet.h mii.c mii.h
  group cmsis
    ../../cmsis/: system_MK60D.c system_MK60D.h
  group CoOS
    ../../../../../CoOS/kernel/: coocox.h CoOS.h core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c OsCore.h OsError.h OsEvent.h OsFlag.h OsKernelHeap.h OsMM.h OsMutex.h OsQueue.h OsServiceReq.h OsTask.h OsTime.h OsTimer.h queue.c sem.c serviceReq.c task.c time.c timer.c utility.c utility.h
  group CoOS/port
    ../../../../../CoOS/portable/: arch.c OsArch.h
    ../../../../../CoOS/portable/IAR/: portForM4.asm
