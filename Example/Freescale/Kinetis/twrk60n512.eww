<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\blink\IAR\blink_twrk60n512.ewp</path>
  </project>
  <batchBuild/>
</workspace>


