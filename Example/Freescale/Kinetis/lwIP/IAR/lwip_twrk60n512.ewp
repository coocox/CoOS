# IAR project lwip_twrk60n512.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\..\BSPLIB\inc; ..\..\BSPLIB\src; ..\..\cmsis; ..\..\cmsis\include; ..\..\..\..\..\CoOS\portable; ..\..\..\..\..\CoOS\kernel; ..\lwip-1.4.1\src\include; ..\lwip-1.4.1\src\include\ipv4; ..\lwip_port
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: lwip_twrk60n512.srec
  ILINK.IlinkIcfFile: 512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: httpserver-netconn.c main.c OsConfig.h
    ./: isr.h low_init.c vectors.c vectors.h
  group BSPLIB/enet
    ../../BSPLIB/src/enet/: enet.h mii.c mii.h
  group CoOS
    ../../../../../CoOS/kernel/: coocox.h CoOS.h core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c OsCore.h OsError.h OsEvent.h OsFlag.h OsKernelHeap.h OsMM.h OsMutex.h OsQueue.h OsServiceReq.h OsTask.h OsTime.h OsTimer.h queue.c sem.c serviceReq.c task.c time.c timer.c utility.c utility.h
  group CoOS/port
    ../../../../../CoOS/portable/: arch.c OsArch.h
    ../../../../../CoOS/portable/IAR/: portForM4.asm
  group lwip_1.4.1/api
    ../lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_1.4.1/core
    ../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip_1.4.1/core/ipv4
    ../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip_1.4.1/netif
    ../lwip-1.4.1/src/netif/: etharp.c
  group lwip_port
    ../lwip_port/: ethernetif.c ethernetif.h lwipopts.h
    ../lwip_port/arch/: sys_arch.c
